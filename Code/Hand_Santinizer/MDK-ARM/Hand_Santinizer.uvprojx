# Keil uVision project Hand_Santinizer.uvprojx, settings and files
target Hand_Santinizer (5060960::V5.06 update 7 (build 960)::.\Arm_Compiler_5.06u7)
  device: STM32L011F4Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x200007FF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: Hand_Santinizer +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L011xx
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Application/MDK-ARM
    ./: startup_stm32l011xx.s
  group Application/User/Core
    ../Core/Src/: ssd1331.c main.c stm32l0xx_it.c stm32l0xx_hal_msp.c
    ../Core/Inc/: ssd1331.h
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group fonts
    ../Core/Inc/fonts/: _images.h Font_3_Picopixel.h Font_3_Tiny.h Font_3_TomThumb_Extended.h Font_5_Org.h Font_8_Default.h Font_8_Myke.h Font_8_Retro.h Font_8_Sinclair.h Font_8_Sinclair_Inverted.h Font_8_Tiny.h Font_9_Mono.h Font_9_Mono_Bold.h Font_9_Mono_Bold_Oblique.h Font_9_Mono_Oblique.h Font_9_Sans.h Font_9_Sans_Bold.h Font_9_Sans_Bold_Oblique.h Font_9_Sans_Oblique.h Font_9_Serif.h Font_9_Serif_Bold.h Font_9_Serif_Bold_Italic.h Font_9_Serif_Italic.h Font_12_Mono.h Font_12_Mono_Bold.h Font_12_Mono_Bold_Oblique.h Font_12_Mono_Oblique.h Font_12_Sans.h Font_12_Sans_Bold.h Font_12_Sans_Bold_Oblique.h Font_12_Sans_Oblique.h Font_12_Serif.h Font_12_Serif_Bold.h Font_12_Serif_Bold_Italic.h Font_12_Serif_Italic.h Font_16_Arial.h Font_16_Arial_Bold.h Font_16_Arial_Italic.h Font_16_Arial_Round.h Font_16_Default.h Font_16_FranklinGothic.h Font_16_Grotesk.h Font_16_Grotesk_Bold.h Font_16_Hallfetica.h Font_16_Matrix_Full.h Font_16_Matrix_Full_Slash.h Font_16_Matrix_Num.h Font_16_Nadianne.h Font_16_OCR.h Font_16_Retro.h Font_16_Segment_16_Full.h Font_16_Sinclair.h Font_16_Sinclair_Inverted.h Font_16_Swiss_Outline.h Font_18_Mono.h Font_18_Mono_Bold.h Font_18_Mono_Bold_Oblique.h Font_18_Mono_Oblique.h Font_18_Sans.h Font_18_Sans_Bold.h Font_18_Sans_Bold_Oblique.h Font_18_Sans_Oblique.h Font_18_Serif.h Font_18_Serif_Bold.h Font_18_Serif_Bold_Italic.h Font_18_Serif_Italic.h Font_24_Grotesk.h Font_24_Grotesk_Bold.h Font_24_Inconsola.h Font_24_Matrix_Num.h Font_24_Mono.h Font_24_Mono_Bold.h Font_24_Mono_Bold_Oblique.h Font_24_Mono_Oblique.h Font_24_Sans.h Font_24_Sans_Bold.h Font_24_Sans_Bold_Oblique.h Font_24_Sans_Oblique.h Font_24_Segment_16_Full.h Font_24_Serif.h Font_24_Serif_Bold.h Font_24_Serif_Bold_Italic.h Font_24_SerifItalic.h Font_24_Ubuntu.h Font_24_Ubuntu_Bold.h Font_32_Arial_Num_Plus.h Font_32_Calibri_Bold.h Font_32_Dingbats.h Font_32_Grotesk.h Font_32_Grotesk_Bold.h Font_32_Matrix_Num.h Font_32_Segment_7_Full.h Font_32_Segment_7_Num_Plus.h Font_32_Segment_16_Full.h Font_32_Segment_18_Full.h Font_32_Special.h Font_40_Segment_16_Full.h Font_48_Battery.h Font_48_Segment_16_Num.h Font_64_Segment_7_Num.h Font_64_Segment_16_Num.h
software components: CMSIS:CORE 4.3.0
